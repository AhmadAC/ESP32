# Keil uVision project template.uvproj, settings and files
target STC89 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\App\inc;..\Hardware\inc
  group Startup
    ./: STARTUP.A51
  group App
    ../App/src/: main.c protocol.c
  group Hardware
    ../Hardware/src/: led.c uart.c delay.c key.c
